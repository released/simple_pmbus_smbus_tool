# Keil uVision project ISP_HID.uvprojx, settings and files
target ISP_HID (6220000::V6.22::ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.7
  cpu: IRAM(0x20000000,0x17FC0) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: ISP_HID +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x17fc0
  scatter file: .\m261_iap_hid_64k.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
    ../../../Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
  group User
    ../: main.c descriptors.c hid_transfer.c fmc_user.c isp_user.c targetdev.c
    ../../../Library/StdDriver/src/: crc.c
  group Library
    ../../../Library/StdDriver/src/: MKROMLib_Keil.lib
